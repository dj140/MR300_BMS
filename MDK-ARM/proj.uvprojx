# Keil uVision project proj.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32E103CB GigaDevice
  pack: GigaDevice.GD32E10x_DFP.1.2.1
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: proj +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARDUINO=111,USE_STDPERIPH_DRIVER,GD32E10X,GD32E103V_EVAL
  c misc: --gnu
  c include: ..\ArduinoAPI;..\Core;..\Libraries;..\USER;..\Libraries\bq769x0;..\Libraries\ButtonEvent;..\Libraries\MillisTaskManager
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ../USER/: main.cpp Handle_Buttons.cpp Handle_LED.cpp Handle_BMS.cpp
  group Libraries
    ../Libraries/bq769x0/: bq769x0.cpp
    ../Libraries/ButtonEvent/: ButtonEvent.cpp
    ../Libraries/MillisTaskManager/: MillisTaskManager.cpp
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c HardwareSerial.cpp itoa.c Print.cpp WString.cpp Wire.cpp WireBase.cpp WMath.cpp SPI.cpp Stream.cpp Tone.cpp
  group Core
    ../Core/: adc.c exti.c gpio.c pwm.c timer.c
    ../CORE/: delay.c
  group README
    ../: README.md
software components: CMSIS:CORE 5.4.0, Device:GD32E10x_StdPeripherals:ADC 1.2.0, Device:GD32E10x_StdPeripherals:BKP 1.2.0, Device:GD32E10x_StdPeripherals:CRC 1.2.0, Device:GD32E10x_StdPeripherals:CTC 1.2.0, Device:GD32E10x_StdPeripherals:DAC 1.2.0, Device:GD32E10x_StdPeripherals:DBG 1.2.0, Device:GD32E10x_StdPeripherals:DMA 1.2.0, Device:GD32E10x_StdPeripherals:EXMC 1.2.0, Device:GD32E10x_StdPeripherals:EXTI 1.2.0, Device:GD32E10x_StdPeripherals:FMC 1.2.0, Device:GD32E10x_StdPeripherals:FWDGT 1.2.0, Device:GD32E10x_StdPeripherals:GPIO 1.2.0, Device:GD32E10x_StdPeripherals:I2C 1.2.0, Device:GD32E10x_StdPeripherals:MISC 1.2.0, Device:GD32E10x_StdPeripherals:PMU 1.2.0, Device:GD32E10x_StdPeripherals:RCU 1.2.0, Device:GD32E10x_StdPeripherals:RTC 1.2.0, Device:GD32E10x_StdPeripherals:SPI_I2S 1.2.0, Device:GD32E10x_StdPeripherals:TIMER 1.2.0, Device:GD32E10x_StdPeripherals:USART 1.2.0, Device:GD32E10x_StdPeripherals:WWDGT 1.2.0, Device:GD32E10x_libopt 1.2.0, Device:Startup 1.2.0
